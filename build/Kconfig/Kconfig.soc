## build/Kconfig/Kconfig.soc.arch
```kconfig
osource "/home/alex/zephyrproject/zephyr/soc/$(ARCH)/Kconfig"
osource "/home/alex/zephyrproject/zephyr/soc/$(ARCH)/*/Kconfig"
```
